# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_2_Images_UserApp (6140000::V6.14::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.1
  cpu: IRAM1(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$L..\@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . .\#L .\@L.bin 1 1
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stmpe1600;../../../../../../Drivers/BSP/Components/stmpe811;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../2_Images_SECoreBin/Inc;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: UserApp.sct
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/B-L475E-IOT01_2_Images_SBSFU/: se_interface.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Application/User
    ../Src/: flash_if.c main.c se_user_code.c stm32l4xx_it.c fw_update_app.c common.c test_protections.c ymodem.c com.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_qspi.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_crc.c stm32l4xx_hal_uart.c stm32l4xx_hal_qspi.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
software components: CMSIS:CORE 5.4.0
