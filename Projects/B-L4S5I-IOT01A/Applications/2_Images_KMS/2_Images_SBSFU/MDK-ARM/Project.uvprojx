# Keil uVision project Project.uvprojx, settings and files
target B-L4S5I-IOT01_2_Images_SBSFU (6140000::V6.14::ARMCLANG)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.1
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SBSFU
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L4S5xx,USE_HAL_DRIVER,USE_STM32L4S5I_IOT01,KMS_ENABLED,ENABLE_IMAGE_STATE_HANDLING,MBEDTLS_CONFIG_FILE=<sfu_scheme_x509_config_mbedtls.h>
  c misc: -Wno-format
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L4S5I-IOT01A;../../../../../../Drivers/BSP/Components/Common;../Core/Inc;../SBSFU/App;../SBSFU/Target;../../2_Images_SECoreBin/Inc;../../Linker_Common/MDK-ARM;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Interface;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST\STM32_Key_Management_Services/iKMS;../../../../../../Middlewares/Third_Party/mbedTLS/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: SBSFU.sct
  link misc: --symdefs=se_interface_appli.txt
--keep=SE_CORE_Bin.o(SE_CORE_Bin)
  group Application/Core
    ../Core/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32l4s5xx.s
    ./: SE_CORE_Bin.s
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_loader.c sfu_boot.c sfu_com_loader.c sfu_com_trace.c sfu_error.c sfu_test.c sfu_fwimg_common.c sfu_fwimg_swap.c sfu_fwimg_no_swap.c sfu_new_image.c sfu_kms.c sfu_interface_crypto_scheme.c sfu_scheme_x509_mbedtls_ecdsa_verify.c sfu_scheme_x509_core.c sfu_scheme_x509_crt.c
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level.c sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c sfu_low_level_security.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L4S5I-IOT01A
    ../../../../../../Drivers/BSP/B-L4S5I-IOT01A/: stm32l4s5i_iot01.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c
  group Middlewares/STM32_Key_Management_Services
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/iKMS/: se_interface_kms.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c
  group Middlewares/Third_Party/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
software components: CMSIS:CORE 5.4.0
